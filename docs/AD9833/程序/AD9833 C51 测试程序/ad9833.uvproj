# Keil uVision project ad9833.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB (AN21XX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) CLOCK(24000000) MODDP2
  output: ad9833i +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\AD9833
  group main
    ./: main.c
  group AD9833
    ./AD9833/: AD9833.c
